v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {code_shown.sym} -60 -500 0 0 {name=s2 only_toplevel=false value=".lib /usr/local/share/pdk/sky130A/libs.tech/ngspice/sky130.lib.spice tt
.tran 0.1ns 100ns
.save all



"}
C {lab_pin.sym} -190 -760 1 0 {name=p16 sig_type=std_logic lab=Vdd
}
C {lab_pin.sym} 120 -780 3 1 {name=p17 sig_type=std_logic lab=A0
}
C {lab_pin.sym} -300 -600 1 0 {name=p18 sig_type=std_logic lab=B0}
C {gnd.sym} -300 -540 0 0 {name=l5 lab=GND}
C {gnd.sym} -90 -540 0 1 {name=l6 lab=GND}
C {gnd.sym} -190 -700 0 0 {name=l7 lab=GND}
C {vsource.sym} -300 -570 0 1 {name=V3 value=1.8 savecurrent=false}
C {vsource.sym} -190 -730 0 1 {name=V9 value=1.8 savecurrent=false}
C {vsource.sym} -90 -570 0 1 {name=V1 value=0 savecurrent=false}
C {lab_pin.sym} 160 -540 1 1 {name=p7 sig_type=std_logic lab=A2
}
C {lab_pin.sym} 200 -540 1 1 {name=p10 sig_type=std_logic lab=A3
}
C {lab_pin.sym} 140 -540 3 0 {name=p5 sig_type=std_logic lab=B1}
C {lab_pin.sym} -60 -840 0 0 {name=p3 sig_type=std_logic lab=B0}
C {lab_pin.sym} 350 -840 0 0 {name=p4 sig_type=std_logic lab=B0}
C {lab_pin.sym} 170 -780 0 0 {name=p11 sig_type=std_logic lab=B0}
C {lab_pin.sym} 240 -780 1 0 {name=p12 sig_type=std_logic lab=Vdd
}
C {lab_pin.sym} -40 -840 3 1 {name=p13 sig_type=std_logic lab=A0
}
C {lab_pin.sym} -20 -840 3 1 {name=p14 sig_type=std_logic lab=A0
}
C {lab_pin.sym} 370 -840 3 1 {name=p15 sig_type=std_logic lab=A0
}
C {lab_pin.sym} 410 -840 3 1 {name=p19 sig_type=std_logic lab=A0
}
C {lab_pin.sym} 0 -840 1 0 {name=p20 sig_type=std_logic lab=B0}
C {lab_pin.sym} 390 -840 1 0 {name=p21 sig_type=std_logic lab=B0}
C {lab_pin.sym} 220 -540 1 1 {name=p6 sig_type=std_logic lab=A4
}
C {lab_pin.sym} 370 -670 1 1 {name=p1 sig_type=std_logic lab=CY
}
C {lab_pin.sym} -90 -600 3 1 {name=p2 sig_type=std_logic lab=A0
}
C {/home/safal/projects/GitHub_CMOS_4bit_ALU/ALU_TOP_MODEL/ALU.sym} 850 -660 0 0 {name=x1}
